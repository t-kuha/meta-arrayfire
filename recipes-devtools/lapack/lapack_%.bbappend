PACKAGECONFIG += " lapacke"
